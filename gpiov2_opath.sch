v {xschem version=2.9.9 file_version=1.2 
* Copyright 2023 David Mitchell Bailey
* 
* Licensed under the Apache License, Version 2.0 (the "License");
* you may not use this file except in compliance with the License.
* You may obtain a copy of the License at
* 
*     https://www.apache.org/licenses/LICENSE-2.0
* 
* Unless required by applicable law or agreed to in writing, software
* distributed under the License is distributed on an "AS IS" BASIS,
* WITHOUT WARRANTIES OR CONDITIONS OF ANY KIND, either express or implied.
* See the License for the specific language governing permissions and
* limitations under the License.
}
G {}
K {}
V {}
S {}
E {}
C {gpiov2_octl_dat.sym} 150 -180 0 0 {name=Xopath_q0 }
C {gpiov2_odrvr_sub.sym} 450 -180 0 0 {name=Xodrvr_q0 }
C {devices/ipin.sym} 0 -290 0 0 {name=p1 lab=DM_H[0]}
C {devices/iopin.sym} -10 -520 0 0 {name=p2 lab=VCC_IO}
C {devices/noconn.sym} 300 -280 0 1 {name=l1}
C {devices/opin.sym} 600 -200 0 0 {name=p3 lab=PAD}
C {devices/opin.sym} 600 -180 0 0 {name=p4 lab=TIE_HI_ESD}
C {devices/opin.sym} 600 -160 0 0 {name=p5 lab=TIE_LO_ESD}
C {devices/noconn.sym} 300 -80 0 1 {name=l2}
C {devices/ipin.sym} 0 -270 0 0 {name=p8 lab=DM_H[1]}
C {devices/ipin.sym} 0 -250 0 0 {name=p9 lab=DM_H[2]}
C {devices/ipin.sym} 0 -230 0 0 {name=p10 lab=DM_H_N[0]}
C {devices/ipin.sym} 0 -210 0 0 {name=p11 lab=DM_H_N[1]}
C {devices/ipin.sym} 0 -190 0 0 {name=p12 lab=DM_H_N[2]}
C {devices/ipin.sym} 0 -170 0 0 {name=p13 lab=HLD_I_H_N}
C {devices/ipin.sym} 0 -150 0 0 {name=p14 lab=HLD_I_OVR_H}
C {devices/ipin.sym} 0 -130 0 0 {name=p15 lab=OD_H}
C {devices/ipin.sym} 0 -110 0 0 {name=p16 lab=OE_N}
C {devices/ipin.sym} 0 -90 0 0 {name=p17 lab=OUT}
C {devices/ipin.sym} 0 -70 0 0 {name=p18 lab=SLOW}
C {devices/iopin.sym} -10 -500 0 0 {name=p19 lab=VPWR}
C {devices/iopin.sym} -10 -480 0 0 {name=p20 lab=VPWR_KA}
C {devices/iopin.sym} -10 -460 0 0 {name=p21 lab=VGND}
C {devices/iopin.sym} -10 -440 0 0 {name=p22 lab=VGND_IO}
C {common/gnd.sym} 90 0 0 0 {name=l3 lab=VGND}
C {common/vdd.sym} 70 -360 0 0 {name=l4 lab=VCC_IO}
C {common/vdd.sym} 450 -290 0 0 {name=l5 lab=VCC_IO}
C {common/vdd.sym} 150 -360 0 0 {name=l6 lab=VPWR}
C {common/vdd.sym} 230 -360 0 0 {name=l7 lab=VPWR_KA}
C {common/gnd.sym} 210 0 0 0 {name=l8 lab=VGND_IO}
C {common/gnd.sym} 450 -70 0 0 {name=l9 lab=VGND_IO}
